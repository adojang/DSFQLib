* Author: Adriaan van Wijk
* Version: 1.0
* Last modification date: 21 July 2022
* Last modification by: Adriaan van Wijk

* Copyright (c) 2022 Adriaan van Wijk, Stellenbosch University

* Permission is hereby granted, free of charge, to any person obtaining a copy
* of this cell library and associated documentation files (the "Library"), to deal
* in the Library without restriction, including without limitation the rights
* to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
* copies of the Library, and to permit persons to whom the Library is
* furnished to do so, subject to the following conditions:

* The above copyright notice and this permission notice shall be included in all
* copies or substantial portions of the Library.

* THE LIBRARY IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
* IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
* FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
* AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
* LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
* OUT OF OR IN CONNECTION WITH THE LIBRARY OR THE USE OR OTHER DEALINGS IN THE
* LIBRARY.

*For questions about the library, contact Adriaan van Wijk, 21786275@sun.ac.za

*********************************
* Additional Notes

* The throughput for this logic cell is approximately 48ps.
* The Cout line only has a delay of 15ps. An adder chain of 4 bits was sucessfully tested without balancing it.
* If longer adder chains are required, it may be neccesary to balance the Cout line at intervals.

.include cells\AW_mitll_AND_optimized.cir
.include cells\AW_mitll_OR_optimized.cir
.include cells\AW_mitll_XOR.cir
.include cells\LSmitll_BUFF_v2p1_optimized.cir

.subckt FULL_ADDER A B Cin Cout S
XXOR1 DSFQ_XOR A B 1
XXOR2 DSFQ_XOR 1 Cin S

XAND1 DSFQ_AND A B 3
XAND2 DSFQ_AND 1 Cin 4
XOR1 DSFQ_OR 4 3 Coutx
XSTABLE LSMITLL_JTL Coutx CoutStable
XBUFF LSMITLL_BUFF CoutStable Cout
.ends
